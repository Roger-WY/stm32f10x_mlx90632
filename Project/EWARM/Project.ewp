# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\Libraries\CMSIS\Include; ..\..\User\bsp; ..\..\User\bsp\inc; ..\..\User\app; ..\..\SEGGER\RTT\RTT; ..\..\SEGGER\HARDFAULTHANDLER\HardFaultHandlerIAR; ..\..\ModbusRTU\inc; ..\..\Irmp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f3.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../../User/app/: app_var.h global.h includes.h main.c stm32f10x_assert.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h
  group BSP/Driver
    ../../User/bsp/src/: bsp_iwdg.c bsp_key.c bsp_led.c bsp_mlx90632.c bsp_timer.c bsp_uart_fifo.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group Doc
    ../../: README.md
  group EWARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
  group ModbusRTU
    ../../ModbusRTU/inc/: modbus_cfg.h modbus_host.h modbus_slave.h
    ../../ModbusRTU/src/: modbus_host.c modbus_slave.c
  group SEGGER/RTT
    ../../SEGGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
